# Keil uVision project lcd_tester.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89LV55 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x4FFF) CLOCK(12000000)
  output: lcd_tester +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: uart.c lcd_window.c main.c lcd_window.h main.h STC12C5A.h uart.h
