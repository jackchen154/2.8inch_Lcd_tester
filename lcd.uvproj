# Keil uVision project lcd.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89F52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: lcd +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: debug_lcd.c 1602.h
    C:/Documents and Settings/Administrator/桌面/实验室/: STC12C5A.h
